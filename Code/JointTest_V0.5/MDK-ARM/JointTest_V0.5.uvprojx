# Keil uVision project JointTest_V0.5.uvprojx, settings and files
target JointTest_V0.5 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32G431CBYx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: JOINT_APP_TESTED +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../BSP/ADC/Inc;../BSP/CRC/Inc;../BSP/DMA/Inc;../BSP/DRV8316/Inc;../BSP/KTH5701/Inc;../BSP/KTH7816/Inc;../BSP/Motor/Inc;../BSP/TIM/Inc;../BSP/UART/Inc;../APP/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\JOINT_APP_V4.sct
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c dma.c i2c.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group BSP
    ../BSP/ADC/Src/: bsp_adc.c
    ../BSP/CRC/Src/: bsp_crc.c
    ../BSP/DMA/Src/: bsp_dma.c
    ../BSP/DRV8316/Src/: bsp_drv8316.c
    ../BSP/KTH5701/Src/: bsp_kth5701.c kth5701.c
    ../BSP/KTH7816/Src/: kth7816.c
    ../BSP/Motor/Src/: Motor.c
    ../BSP/TIM/Src/: bsp_tim.c
    ../BSP/UART/Src/: bsp_uart.c msuart.c
  group APP
    ../APP/Src/: test.c
software components: CMSIS:CORE 5.4.0
