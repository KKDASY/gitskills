# Keil uVision project MainTest_V0.5.uvprojx, settings and files
target MainTest_V0.5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G431C8Ux STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MainTest_V0.5 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../USB_Device/App;../USB_Device/Target;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\BSP\CRC\Inc;..\BSP\DMA\Inc;..\BSP\KEY\Inc;..\BSP\KTH5701\Inc;..\BSP\LED\Inc;..\BSP\TIM\Inc;..\BSP\TPS26400\Inc;..\BSP\UART\Inc;..\APP\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dma.c i2c.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group BSP
    ../BSP/CRC/Src/: bsp_crc.c
    ../BSP/DMA/Src/: bsp_dma.c
    ../BSP/KEY/Src/: bsp_key.c
    ../BSP/KTH5701/Src/: bsp_kth5701.c kth5701.c
    ../BSP/LED/Src/: bsp_led.c
    ../BSP/TIM/src/: bsp_tim.c
    ../BSP/TPS26400/Src/: bsp_tps26400.c
    ../BSP/UART/Src/: bsp_uart.c msuart.c
  group APP
    ../APP/Src/: test.c
software components: CMSIS:CORE 4.3.0
